Commit message: final

File: drake/box.urdf (robot description, URDF)
Before this commit: robot square_peg, 1 links, 0 joints
Links:
- removed link peg_link
- added link box_link, mass 1; collision box size=1. 1. 2.; visual box size=1. 1. 2.
